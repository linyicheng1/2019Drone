# Keil uVision project 2019Drone_V2.uvprojx, settings and files
target STM32_USART1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 2019Drone_V2 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\user;.\Hardware;.\device;.\algorithm;.\modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./startup/: startup_stm32f10x_cl.s
  group User
    ./user/: main.c stm32f10x_it.c
  group Hardware
    ./Hardware/: drv_can.c drv_dma.c drv_gpio.c drv_tim.c drv_usart.c drv_nvic.c
  group StdPeriph_Drive
    ./FWlib/SRC/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_can.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_usart.c
  group CMSIS
    ./user/: core_cm3.c system_stm32f10x.c
  group Device
    ./device/: dshot.c DataScope_DP.C dbus.c motor.c IMU.c
  group Algorithm
    ./algorithm/: algorithmOfCRC.c pid.c ZeroCheck.c
  group Modules
    ./modules/: gimbal.c shoot.c modules.c
